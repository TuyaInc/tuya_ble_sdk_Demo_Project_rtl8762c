# Keil uVision project tuya_ble_sdk_Demo_Project_rtl8762c.uvprojx, settings and files
target tuya_ble_standard_rtl8762c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<custom_tuya_ble_config.h>
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;.\sample;.\;.\sample\tuya_ble_app;.\sample\tuya_ble_sdk;.\sample\tuya_ble_sdk\port\realtek;.\sample\tuya_ble_sdk\port;.\sample\tuya_ble_sdk\sdk\include;.\sample\tuya_ble_sdk\sdk\lib;.\sample\tuya_ble_services;.\sample\tuya_ble_sdk\extern_components\mbedtls;.\sample\tuya_ble_sdk\app\product_test;.\sample\tuya_ble_sdk\app\uart_common
  asm misc: --cpreproc
  asm include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;.\sample;..\tuya_ble_standard_rtl8762c;.\sample\tuya_ble_app;.\sample\tuya_ble_sdk;.\sample\tuya_ble_sdk\port\realtek;.\sample\tuya_ble_sdk\port;.\sample\tuya_ble_sdk\sdk\include;.\sample\tuya_ble_sdk\sdk\lib;.\sample\tuya_ble_services
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
    ./: flash_map.h mem_config.h otp_config.h
    ./sample/: app_flags.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib bee2_sdk.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_rcc.c rtl876x_uart.c
    ../../../src/hw_aes/: hw_aes.c
  group app
    ./sample/: app_task.c main.c peripheral_app.c uart.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
  group tuya_ble_services
    ./sample/tuya_ble_services/: tuya_ble_service_rtl8762c.c
  group tuya_ble_app_demo
    ./sample/tuya_ble_app/: tuya_ble_app_demo.c tuya_ble_app_ota.c custom_app_product_test.c custom_app_uart_common_handler.c
    ./: custom_tuya_ble_config.h
  group tuya_ble_sdk
    ./sample/tuya_ble_sdk/sdk/src/: tuya_ble_api.c tuya_ble_data_handler.c tuya_ble_event.c tuya_ble_event_handler.c tuya_ble_event_handler_weak.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_mutli_tsf_protocol.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_utils.c tuya_ble_queue.c tuya_ble_gatt_send_queue.c
    ./sample/tuya_ble_sdk/port/: tuya_ble_port.c tuya_ble_port_peripheral.c
    ./sample/tuya_ble_sdk/sdk/include/: tuya_ble_queue.h tuya_ble_gatt_send_queue.h
    ./sample/tuya_ble_sdk/app/product_test/: tuya_ble_app_production_test.c
    ./sample/tuya_ble_sdk/app/uart_common/: tuya_ble_app_uart_common_handler.c
  group tuya_ble_lib
    ./sample/tuya_ble_sdk/sdk/lib/: tuya_ble_sdk_lib_arm_m4f.lib
  group extern_components_mbedTLS
    ./sample/tuya_ble_sdk/extern_components/mbedtls/: hmac.c md5.c sha1.c sha256.c
  group tuya_ble_sdk_port
    ./sample/: tuya_ble_port_rtl8762.c
